# IAR project RCoS2_100.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA2L1AB Renesas R7FA2L1AB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: _RENESAS_RA_; ENERGYMONITORING; New_algorithm; SERVICEMODEavailable; COMP_AVAILABLE=1; ResetRecord; _RA_ORDINAL=1; _RA_CORE=CM23
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\sources; ..\sources\app; ..\sources\dev; ..\sources\rcos; ..\sources\board; ..\sources\SEGGER_RTT; ..\sources\SEGGER_RTT\Config; ..\sources\SEGGER_RTT\Syscalls; renesas; renesas\ra; renesas\ra\arm; renesas\ra\arm\CMSIS_5; renesas\ra\arm\CMSIS_5\CMSIS; renesas\ra\arm\CMSIS_5\CMSIS\Core; renesas\ra\arm\CMSIS_5\CMSIS\Core\Include; renesas\ra\fsp; renesas\ra\fsp\inc; renesas\ra\fsp\inc\api; renesas\ra\fsp\inc\instances; renesas\ra\fsp\src; renesas\ra\fsp\src\bsp; renesas\ra\fsp\src\bsp\mcu; renesas\ra\fsp\src\bsp\mcu\all; renesas\ra\fsp\src\bsp\mcu\ra2e1; renesas\ra\fsp\src\bsp\cmsis; renesas\ra\fsp\src\bsp\cmsis\Device; renesas\ra\fsp\src\bsp\cmsis\Device\RENESAS; renesas\ra\fsp\src\bsp\cmsis\Device\RENESAS\Include; renesas\ra\fsp\src\bsp\cmsis\Device\RENESAS\Source; renesas\ra\fsp\src\r_adc; renesas\ra\fsp\src\r_agt; renesas\ra\fsp\src\r_cgc; renesas\ra\fsp\src\r_flash_lp; renesas\ra\fsp\src\r_gpt; renesas\ra\fsp\src\r_icu; renesas\ra\fsp\src\r_iic_master; renesas\ra\fsp\src\r_ioport; renesas\ra\fsp\src\r_wdt; renesas\ra\fsp\src\r_lvd; renesas\ra\fsp\src\r_sci_uart; renesas\ra\fsp\src\r_spi; renesas\ra_cfg; renesas\ra_cfg\fsp_cfg; renesas\ra_cfg\fsp_cfg\bsp; renesas\ra_gen; renesas\script; renesas\src; ..\sources; ..\sources\SEGGER_RTT\Config; ..\sources\SEGGER_RTT; ..\sources\SEGGER_RTT\Syscalls; ..\sources\app; ..\sources\board; ..\sources\rcos; ..\sources\rcos\core; ..\sources\rcos\dev; ..\sources\rcos\dev/ra2; ..\sources\rcos\libs; ..\sources\rcos\mw; ..\sources\dev; ..\sources\init; ..\sources\init\arch; ..\sources\rcos\mw\Connectivity; ..\sources\rcos\dev\ra2; ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RA_; _RA_ORDINAL=1; _RA_CORE=CM23
  AARM.AUserIncludes: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RCoS2_100.hex
  postbuild: "scripts\Build_Script_Runner_app.bat"
  ILINK.IlinkOutputFile: RCoS2_100.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_; _RA_ORDINAL=1; _RA_CORE=CM23
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily ra "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ra_cfg/fsp_cfg/: r_adc_cfg.h r_flash_lp_cfg.h r_gpt_cfg.h r_iic_master_cfg.h r_ioport_cfg.h r_sci_uart_cfg.h r_spi_cfg.h r_wdt_cfg.h
  group Flex Software/Components
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_adc_api.h r_cgc_api.h r_elc_api.h r_flash_api.h r_i2c_master_api.h r_ioport_api.h r_spi_api.h r_timer_api.h r_transfer_api.h r_uart_api.h r_wdt_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra2l1/: bsp_elc.h bsp_feature.h bsp_icu.h bsp_mcu_info.h bsp_power.c bsp_power.h
    ra/arm/CMSIS_5/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/arm/CMSIS_5/: LICENSE.txt
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA2L1AB.h renesas.h system.h
    ra/fsp/src/r_adc/: r_adc.c
    ra/fsp/inc/instances/: r_adc.h r_flash_lp.h r_gpt.h r_iic_master.h r_ioport.h r_sci_uart.h r_spi.h r_wdt.h
    ra/fsp/src/r_flash_lp/: r_flash_lp.c
    ra/fsp/src/r_gpt/: r_gpt.c
    ra/fsp/src/r_iic_master/: r_iic_master.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_sci_uart/: r_sci_uart.c
    ra/fsp/src/r_spi/: r_spi.c
    ra/fsp/src/r_wdt/: r_wdt.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
  group sources
    ../sources/: rcos.c rcos.h system.c system.h
  group sources/app/cabin
    ../sources/app/cabin/: cabin.c cabin.h cabin_configs.h cabin_ram.h cabin_sets.h
  group sources/app/cabin/cabin_ff
    ../sources/app/cabin/cabin_ff/: cabin_ff.c cabin_ff.h
  group sources/app/cabin/cabin_ff/components
    ../sources/app/cabin/cabin_ff/components/: cabin_ff_d_heater.c cabin_ff_d_heater.h cabin_ff_fan.c cabin_ff_fan.h cabin_ff_lt_heater.c cabin_ff_lt_heater.h
  group sources/app/cabin/cabin_ff/procedures
    ../sources/app/cabin/cabin_ff/procedures/: cabin_ff_cool.c cabin_ff_cool.h cabin_ff_defrost.c cabin_ff_defrost.h
  group sources/app/cabin/cabin_flap
    ../sources/app/cabin/cabin_flap/: cabin_flap.c cabin_flap.h
  group sources/app/cabin/cabin_flap/components
    ../sources/app/cabin/cabin_flap/components/: cabin_flap_chl_heater.c cabin_flap_chl_heater.h cabin_flap_fan.c cabin_flap_fan.h cabin_flap_flap.c cabin_flap_flap.h cabin_flap_flap_heater.c cabin_flap_flap_heater.h cabin_flap_lt_heater.c cabin_flap_lt_heater.h
  group sources/app/cabin/cabin_flap/procedures
    ../sources/app/cabin/cabin_flap/procedures/: cabin_flap_cool.c cabin_flap_cool.h
  group sources/app/cabin/cabin_frz
    ../sources/app/cabin/cabin_frz/: cabin_frz.c cabin_frz.h
  group sources/app/cabin/cabin_frz/components
    ../sources/app/cabin/cabin_frz/components/: cabin_frz_d_heater.c cabin_frz_d_heater.h cabin_frz_fan.c cabin_frz_fan.h
  group sources/app/cabin/cabin_frz/procedures
    ../sources/app/cabin/cabin_frz/procedures/: cabin_frz_cool.c cabin_frz_cool.h cabin_frz_defrost.c cabin_frz_defrost.h
  group sources/app/cabin/cabin_jkr
    ../sources/app/cabin/cabin_jkr/: cabin_jkr.c cabin_jkr.h
  group sources/app/cabin/cabin_jkr/components
    ../sources/app/cabin/cabin_jkr/components/: cabin_jkr_d_heater.c cabin_jkr_d_heater.h cabin_jkr_fan.c cabin_jkr_fan.h cabin_jkr_lt_heater.c cabin_jkr_lt_heater.h
  group sources/app/cabin/cabin_jkr/procedures
    ../sources/app/cabin/cabin_jkr/procedures/: cabin_jkr_cool.c cabin_jkr_cool.h cabin_jkr_defrost.c cabin_jkr_defrost.h
  group sources/app/cabin/components
    ../sources/app/cabin/components/: cabin_a_heater.c cabin_a_heater.h cabin_b_heater.c cabin_b_heater.h cabin_blue_light.c cabin_blue_light.h cabin_c_heater.c cabin_c_heater.h cabin_comp_flap.c cabin_comp_flap.h cabin_fan.c cabin_fan.h cabin_handle_light.c cabin_handle_light.h cabin_inner_light.c cabin_inner_light.h cabin_ionizer.c cabin_ionizer.h cabin_switch.c cabin_switch.h cabin_vacuumbox.c cabin_vacuumbox.h cabin_violed.c cabin_violed.h
  group sources/app/cabin/defaults
    ../sources/app/cabin/defaults/: cabin_defaults.h cabin_defaults_a_heater.h cabin_defaults_b_heater.h cabin_defaults_c_heater.h cabin_defaults_cool.h cabin_defaults_defrost.h cabin_defaults_drainage.h cabin_defaults_fan.h cabin_defaults_flap.h cabin_defaults_performance.h cabin_defaults_quick.h
  group sources/app/cabin/parameters
    ../sources/app/cabin/parameters/: cabin_parameters.h cabin_parameters_a_heater.h cabin_parameters_b_heater.h cabin_parameters_c_heater.h cabin_parameters_cool.h cabin_parameters_defrost.h cabin_parameters_drainage.h cabin_parameters_fan.h cabin_parameters_flap.h cabin_parameters_level.h cabin_parameters_performance.h cabin_parameters_quick.h cabin_parameters_vacuumbox.h cabin_parameters_violed.h
  group sources/app/cabin/procedures
    ../sources/app/cabin/procedures/: cabin_ai_cool.c cabin_ai_cool.h cabin_ai_cool_config.h cabin_commercial_test.c cabin_commercial_test.h cabin_defrost.c cabin_defrost.h cabin_drainage.c cabin_drainage.h cabin_duty.c cabin_duty.h cabin_errors.c cabin_errors.h cabin_fan_level.c cabin_fan_level.h cabin_gas_level.c cabin_gas_level.h cabin_performance.c cabin_performance.h cabin_production_test.c cabin_production_test.h cabin_quick.c cabin_quick.h cabin_sets_proc.c cabin_sets_proc.h cabin_shared_funcs.c cabin_shared_funcs.h
  group sources/app/cabin/states
    ../sources/app/cabin/states/: cabin_states.h cabin_states_a_heater.h cabin_states_b_heater.h cabin_states_c_heater.h cabin_states_cool.h cabin_states_defrost.h cabin_states_fan.h cabin_states_flap.h
  group sources/app/cooler
    ../sources/app/cooler/: cooler.c cooler.h cooler_common.h cooler_configs.h cooler_ram.h
  group sources/app/cooler/components
    ../sources/app/cooler/components/: cooler_ambient_sensors.c cooler_ambient_sensors.h cooler_components.h cooler_cond_fan.c cooler_cond_fan.h cooler_valve.c cooler_valve.h
  group sources/app/cooler/system_state
    ../sources/app/cooler/system_state/: cooler_system_state.c cooler_system_state.h
  group sources/app/cooler/types
    ../sources/app/cooler/types/: cooler_type_default.c cooler_type_parallel.c cooler_type_semi_parallel.c cooler_types.h
  group sources/app/dispenser
    ../sources/app/dispenser/: dispenser.c dispenser.h dispenser_configs.h dispenser_procedures.c dispenser_procedures.h dispenser_ram.h
  group sources/app/ice_machine
    ../sources/app/ice_machine/: ice_machine.c ice_machine.h ice_machine_configs.h ice_machine_procedures.c ice_machine_procedures.h ice_machine_ram.c ice_machine_ram.h
  group sources/app/ice_source
    ../sources/app/ice_source/: ice_source.c ice_source.h ice_source_configs.h ice_source_procedures.c ice_source_procedures.h ice_source_ram.h
  group sources/app/libs
    ../sources/app/libs/: component_test.c component_test.h temp_funcs.c temp_funcs.h
  group sources/app/mw
    ../sources/app/mw/: EE_data.h eeprom_fileds.c eeprom_fileds.h h_backup.c h_backup.h rcos_connectivity.h reset_record.c reset_record.h rf_backup.c rf_backup.h rf_udaq.c rf_udaq.h
  group sources/app/mw/connectivity
    ../sources/app/mw/connectivity/: remote_control.c remote_control.h remote_control_driver.c remote_control_driver.h
  group sources/app/refrigerator
    ../sources/app/refrigerator/: components_configs.h components_ram.h refrigerator.c refrigerator.h rf_common.h rf_configs.h rf_ram.h rf_sets.h wm_ram.h
  group sources/app/refrigerator/procedures
    ../sources/app/refrigerator/procedures/: rf_ai_cool.c rf_ai_cool.h rf_doors_alert.c rf_doors_alert.h rf_doors_closed.c rf_doors_closed.h rf_eco_extra.c rf_eco_extra.h rf_economy.c rf_economy.h rf_errors.c rf_errors.h rf_performance.c rf_performance.h rf_rice.c rf_rice.h rf_sabbath.c rf_sabbath.h rf_shopping_mode.c rf_shopping_mode.h rf_silent.c rf_silent.h rf_vacation.c rf_vacation.h
  group sources/app/ui
    ../sources/app/ui/: ui_proc.c ui_proc.h ui_ram.h
  group sources/app/ui/command_events
    ../sources/app/ui/command_events/: ce_buzzer.c ce_buzzer.h ce_cabin.c ce_cabin.h ce_commercial.c ce_commercial.h ce_dispenser.c ce_dispenser.h ce_display.c ce_display.h ce_distributer.c ce_distributer.h ce_ice_machine.c ce_ice_machine.h ce_normal.c ce_normal.h ce_password.c ce_password.h ce_refrigerator.c ce_refrigerator.h ce_service.c ce_service.h ce_water_source.c ce_water_source.h cmd_check.c cmd_check.h
  group sources/app/ui/components
    ../sources/app/ui/components/: ui_buzzer.c ui_buzzer.h ui_components_ram.h ui_display.c ui_display.h ui_service_button.c ui_service_button.h
  group sources/app/ui/procedures
    ../sources/app/ui/procedures/: ui_errors.c ui_errors.h ui_password.c ui_password.h ui_procedures_ram.h ui_sabbath.c ui_sabbath.h ui_slides.c ui_slides.h ui_wifi.c ui_wifi.h
  group sources/app/ui/states
    ../sources/app/ui/states/: ui_commercial_state.c ui_commercial_state.h ui_distributer_state.c ui_distributer_state.h ui_ftc_state.c ui_ftc_state.h ui_normal_state.c ui_normal_state.h ui_service_state.c ui_service_state.h ui_states.h ui_states_ram.h
  group sources/app/ui/states/service_mode_procedures
    ../sources/app/ui/states/service_mode_procedures/: ui_service_mode_procedures_ram.h ui_sm_components.c ui_sm_components.h ui_sm_parameters.c ui_sm_parameters.h ui_sm_sensors.c ui_sm_sensors.h
  group sources/app/water_source
    ../sources/app/water_source/: water_source.c water_source.h water_source_configs.h water_source_procedures.c water_source_procedures.h water_source_ram.h
  group sources/board
    ../sources/board/: board.c board.h board_bona_ra2l1.c
  group sources/config
    ../sources/config/: metadata.h rf_configs.c rf_sets_cabins.c
  group sources/dev
    ../sources/dev/: ac_output.c ac_output.h bdc_motor.c bdc_motor.h buzzer.c buzzer.h debounce_patch.c debounce_patch.h display_spi.c display_spi.h EEProm_log_map.c EEProm_log_map.h energymonitoring.c energymonitoring.h fan.c fan.h filter.c filter.h inverteruartcomm.c inverteruartcomm.h knob.c knob.h ntc.c ntc.h otaprocess.c otaprocess.h sht3x.c sht3x.h stepper_motor.c stepper_motor.h synchronizer.c synchronizer.h tle941.c tle941.h
  group sources/rcos/core
    ../sources/rcos/core/: core.c core.h
  group sources/rcos/dev
    ../sources/rcos/dev/: 24cxx.c 24cxx.h dev.c dev.h fade.c fade.h pattern.c pattern.h pulse.c pulse.h
  group sources/rcos/dev/ra2
    ../sources/rcos/dev/ra2/: adc.c adc.h data_flash.c data_flash.h gpio.c gpio.h iic_i2c_master.c iic_i2c_master.h platform.c platform.h pwm.c pwm.h spi_slave.c spi_slave.h uart.c uart.h
  group sources/rcos/libs
    ../sources/rcos/libs/: bits.c bits.h crc.c crc.h debug.c debug.h deque.c deque.h hamming.c hamming.h hash.c hash.h json.c json.h libs.h list_dl.c list_dl.h list_sl.c list_sl.h rassert.c rassert.h rcosVersion.h ticket.h utf.c utf.h version.c version.h
  group sources/rcos/mw
    ../sources/rcos/mw/: backup.h udaq_rf.c udaq_rf.h
  group sources/rcos/mw/Connectivity
    ../sources/rcos/mw/Connectivity/: ccm.c ccm.h ccm_safir.c ccm_safir.h consumption.c consumption.h feature.c feature.h gdm.c gdm.h pcm.c pcm.h sensor.c sensor.h wfa.c wfa.h
