<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\RCoS2_100.ewp</path>
    </project>
    <batchBuild/>
</workspace>
